# Keil uVision project Blinky.uvproj, settings and files
target LPC1768 Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 550
  c include: .\PhotoGallery
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: GLCD_SPI_LPC1700.c LED.c IRQ.c Blinky.c KBD.c KBD.h GLCD.h snake.h snake.c PhotoGallery.c PhotoGallery.h galaxy64.c satelite64.c ufo64.c quizgame.c quizgame.h
  group Documentation
    ./: Abstract.txt
  group pics
    ./images/: facedown.c all.c
  group audio
    ./audio/: usbuser.c adcuser.c core_cm3.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.h adcuser.h audio.h core_cm3.h LPC17xx.h type.h usb.h usbaudio.h usbcfg.h usbcore.h usbdesc.h usbhw.h usbreg.h
    ./: usbdmain.h
